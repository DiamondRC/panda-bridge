# Add custom packages to the PandA image.
IMAGE_INSTALL:append = " irq-affinity kernel-module-l2-lockdown"
